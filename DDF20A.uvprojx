# Keil uVision project DDF20A.uvprojx, settings and files
target Release (6140000::V6.14::ARMCLANG)
  device: STM32F767IITx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.12.0
  cpu: IRAM(0x20020000,0x60000) IRAM2(0x20000000,0x20000) IROM(0x08000000,0x200000) IROM2(0x00200000,0x200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: DDF20A +hex
  c flags: OneElfS=1 uC99=1 uGnu=1 v6Lang=6 v6LangP=4 wLevel=3
  c define: USE_HAL_DRIVER,STM32F767xx,_RTE_,ARM_MATH_CM7,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,__FPU_PRESENT=1,__FPU_USED=1
  c include: .\Config;.\Core;.\Drivers\CMSIS\Core\Include;.\Drivers\CMSIS\Device\ST\STM32F7xx\Include;.\Drivers\STM32F7xx_HAL_Driver\Inc;.\Drivers\STM32F7xx_HAL_Driver\Inc\Legacy;.\Drivers\BSP;.\Drivers\BSP\Components;.\GUI\Config;.\GUI\Core\;.\Middlewares\Third_Party\emWin\inc;.\Middlewares\Third_Party\FatFs\src;.\Middlewares\Third_Party\FreeRTOS\Source\include;.\Middlewares\Third_Party\FreeRTOS\Source\portable\GCC\ARM_CM7\r0p1;.\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;.\Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc;.\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;.\Utilities\CPU;.\FATFS\App;.\USB_DEVICE\App;.\Utilities\Fonts;.\RTT;.\EventRecorder;.\Modules
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x80000
  group CMSIS
    ./CMSIS/: system_stm32f7xx.c
  group Config
    ./Config/: sd_diskio_dma_rtos.c usbd_conf.c FreeRTOSConfig.h sd_diskio.c
  group Core
    ./Core/: bsp.c delay.c main.c stm32f7xx_hal_msp.c stm32f7xx_it.c sys.c include.h App_Printf.c
  group Drivers\BSP
    ./Drivers/BSP/: bsp_driver_fmc_sdram.c bsp_driver_led.c bsp_driver_ltdc.c bsp_driver_mpu.c bsp_driver_qspi.c bsp_driver_rtc.c bsp_driver_tftlcd.c bsp_driver_timer.c bsp_driver_touch.c bsp_driver_ts_iic.c bsp_driver_usart.c bsp_driver_wifi.c bsp_driver_fmc_sram.c bsp_driver_gps.c bsp_driver_smbus_gpio.c bsp_driver_bat.c bsp_driver_gpio.c bsp_driver_sd.c bsp_driver_fpga.c bsp_driver_temp.c
  group Drivers\BSP\Components
    ./Drivers/BSP/Components/: ft5206.c gt911.c mx25l256.c w25qxx.c ds18s20.c
  group Drivers\STM32F7xx_HAL_Driver\Src
    ./Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal.c stm32f7xx_hal_cortex.c stm32f7xx_hal_crc.c stm32f7xx_hal_crc_ex.c stm32f7xx_hal_dma.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_gpio.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_pcd.c stm32f7xx_hal_pcd_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_qspi.c stm32f7xx_hal_rcc.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_rtc.c stm32f7xx_hal_rtc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_sdram.c stm32f7xx_hal_smartcard.c stm32f7xx_hal_smartcard_ex.c stm32f7xx_hal_spi.c stm32f7xx_hal_sram.c stm32f7xx_hal_tim.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_uart.c stm32f7xx_hal_usart.c stm32f7xx_ll_fmc.c stm32f7xx_ll_sdmmc.c stm32f7xx_ll_usb.c stm32f7xx_hal_smbus.c
  group FATFS\App
    ./FATFS/App/: fatfs.c
  group GUI\Config
    ./GUI/Config/: GUI_X_Touch_Analog.c GUIConf.c LCDConf_RGB.c
  group GUI\Core
    ./GUI/Core/: GuiTask.c WindowDLG.c
  group MDK-ARM
    ./MDK-ARM/: startup_stm32f767xx.s
  group Middlewares\ST\STM32_USB_Device_Library\Class\MSC\Inc
    ./Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group Middlewares\ST\STM32_USB_Device_Library\Core\Src
    ./Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group Middlewares\Third_Party\emWin\Lib
    ./Middlewares/Third_Party/emWin/Lib/: STemWin_CM7_OS_wc16_ot_ARGB.a
  group Middlewares\Third_Party\emWin\OS
    ./Middlewares/Third_Party/emWin/OS/: GUI_X_FreeRTOS.c
  group Middlewares\Third_Party\FatFs\src
    ./Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c ffsystem.c ffunicode.c
  group Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
    ./Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os2.c
  group Middlewares\Third_Party\FreeRTOS\Source\portable
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/GCC/ARM_CM7/r0p1/: port.c
    ./Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_5.c heap_4.c
  group Middlewares\Third_Party\FreeRTOS\Source
    ./Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Modules
    ./Modules/: fdip.c tdip.c process.c
  group Test
    ./Test/: bsp_ts_test.c emwin_test.c sd_test.c BatTest.c
  group USB_DEVICE\App
    ./USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_storage_if.c
  group Utilities\CPU
    ./Utilities/CPU/: cpu_utils.c
  group Utilities\Font
    ./Utilities/Fonts/: font.c
  group RTT
    ./RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
  group EventRecorder
    ./EventRecorder/: EventRecorder.c retarget_io.c
  group Doc
    ./: README.md
